options:
  parameters:
    author: Efren Acevedo
    category: '[Modulos_J1EG5]'
    copyright: UIS
    generate_options: qt_gui
    id: Modulador_de_amplitud
    output_language: python
    title: Modulador de amplitud
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora (Ac)
    start: '0'
    step: '1e-3'
    stop: '1'
    value: '125e-3'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud del mensaje
    start: '0'
    step: '100e-3'
    stop: '4'
    value: '1'
  states: {}
- name: B
  id: variable_qtgui_range
  parameters:
    label: Cambio de banda
    start: '-1'
    step: '2'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia Trasmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: K
  id: variable_qtgui_range
  parameters:
    label: habilita portadora
    start: '0'
    step: '1'
    stop: '2'
    value: '0.5'
  states: {}
- name: Ka
  id: variable_qtgui_range
  parameters:
    label: Coeficiente de sensibilidad de amplitud
    start: '0'
    step: '0.01'
    stop: '20'
    value: '1'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: 50e6
    step: 1e6
    stop: 02.2e9
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia del mensaje
    start: '300'
    step: '100'
    stop: samp_rate/4
    value: 1e3
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de muestreo
    start: '1000'
    step: '10000'
    stop: 50e6
    value: 1.5625e6
  states: {}
- name: Envolvente_Compleja_0
  id: Envolvente_Compleja
  parameters:
    Ac: K
    Ka: B
  states: {}
- name: Lab3_0
  id: Lab3
  parameters:
    Ac: Ac
    Ka: Ka
  states: {state: disabled}
- name: PruebaPotencia_0
  id: PruebaPotencia
  parameters:
    l_vect: '1024'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Desktop/AbadCristian2/y2mate.com-ACDC-Highway-to-Hell-Official-Video.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: '200000'
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Envolvente_Compleja_0, '0', qtgui_freq_sink_x_1, '0']
- [Envolvente_Compleja_0, '0', qtgui_time_sink_x_0, '0']
- [Envolvente_Compleja_0, '0', uhd_usrp_sink_0, '0']
- [Lab3_0, '0', qtgui_freq_sink_x_1, '0']
- [Lab3_0, '0', qtgui_time_sink_x_0, '0']
- [Lab3_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', Envolvente_Compleja_0, '0']
- [analog_sig_source_x_0, '0', Lab3_0, '0']
- [analog_sig_source_x_0, '0', PruebaPotencia_0, '0']
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', Envolvente_Compleja_0, '0']
- [rational_resampler_xxx_0, '0', Lab3_0, '0']
- [rational_resampler_xxx_0, '0', PruebaPotencia_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
